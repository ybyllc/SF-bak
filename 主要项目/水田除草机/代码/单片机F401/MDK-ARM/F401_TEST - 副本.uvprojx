# Keil uVision project F401_TEST - 副本.uvprojx, settings and files
target F401_TEST (6150000::V6.15::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F401_TEST +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\App\hsc_Lib\1_Task;..\App\hsc_Lib\2_Control;..\App\hsc_Lib\3_Driver;..\App\hsc_Lib\3_Driver\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group 1_Task
    ../App/hsc_Lib/1_Task/: app_main.c app_main.h car-data.c car-data.h common.h car_task.c car_task.h
  group 2_Control
    ../App/hsc_Lib/2_Control/: menu.c menu.h menu_input.c menu_input.h gyro_collision.c gyro_collision.h PID.c PID.h menu_uimenlvg.c menu_uimenlvg.h
  group 3_Driver
    ../App/hsc_Lib/3_Driver/: motor-m.c motor-m.h wit_gyro_sdk.c wit_gyro_sdk.h wit_REG.h soft_iic.h soft_iic.c TOF_VL53L0X.c TOF_VL53L0X.h
    ../App/hsc_Lib/3_Driver/OLED/: oled.c oled.h oledfont.h bmp.h
software components: CMSIS:CORE 5.2.0
