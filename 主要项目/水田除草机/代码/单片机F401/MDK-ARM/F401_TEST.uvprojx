# Keil uVision project F401_TEST.uvprojx, settings and files
target F401_TEST (6150000::V6.15::ARMCLANG)
  device: STM32F401RCTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: F401_TEST +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../App/hsc_Lib/1_Task;../App/hsc_Lib/2_Control;../App/hsc_Lib/3_Driver;../App/hsc_Lib/3_Driver/OLED;../App/hsc_Lib/3_Driver/OLED/lvgl_mode;../App/hsc_Lib/3_Driver/OLED/u8g2;../App/hsc_Lib/3_Driver/OLED/lvgl/src;../App/hsc_Lib/3_Driver/OLED/lvgl/src/core;../App/hsc_Lib/3_Driver/OLED/lvgl/src/draw;../App/hsc_Lib/3_Driver/OLED/lvgl/src/font;../App/hsc_Lib/3_Driver/OLED/lvgl/src/hal;../App/hsc_Lib/3_Driver/OLED/lvgl/src/misc;../App/hsc_Lib/3_Driver/OLED/lvgl/src/widgets;../App/hsc_Lib/3_Driver/OLED/lvgl/src/extra
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f401xc.s
  group Application/User/Core
    ../Core/Inc/: dma.h rtc.h
    ../Core/Src/: main.c gpio.c adc.c dma.c rtc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Core/Inc/: stm32f4xx_hal_conf.h
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group 1_Task
    ../App/hsc_Lib/1_Task/: app_main.c app_main.h car-data.c car-data.h common.h car_task.c car_task.h
  group 2_Control
    ../App/hsc_Lib/2_Control/: menu.c menu.h menu_button.c menu_button.h gyro_collision.c gyro_collision.h PID.c PID.h HMI_uart.c HMI_uart.h debug_uart.c debug_uart.h Cam_uart.c Cam_uart.h
  group 3_Driver
    ../App/hsc_Lib/3_Driver/: wit_gyro_sdk.c wit_gyro_sdk.h wit_REG.h soft_iic.h soft_iic.c TOF_VL53L0X.c TOF_VL53L0X.h ax_ps2.c ax_ps2.h encoder_knob.h encoder_knob.c icm42670.c icm42670.h motor_tb6612.c motor_tb6612.h key_pc6.c key_pc6.h encoder.h encoder.c PWM_standard.c PWM_standard.h servo_pwm.c servo_pwm.h remote_key.c remote_key.h gyro_icm.c gyro_icm.h ppm_input.c ppm_input.h ppm_output.c ppm_output.h sbus_input.c sbus_input.h sbus_output.c sbus_output.h ultrasonic_sr04.c ultrasonic_sr04.h
    ../App/hsc_Lib/3_Driver/OLED/: oledfont.h bmp.h
  group OLED
    ../App/hsc_Lib/3_Driver/OLED/: oled_ui_mode.h oled.c oled.h bmp.h oledfont.h oled_u8g2.c
  group OLED/u8g2
    ../App/hsc_Lib/3_Driver/OLED/u8g2/: mui.c mui_u8g2.c u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c u8g2.h
software components: CMSIS:CORE 5.2.0
